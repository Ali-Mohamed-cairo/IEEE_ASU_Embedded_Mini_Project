# Keil uVision project On_Demand_Source_Code.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: On_Demand_Source_Code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: RCC_config.h RCC_interface.h RCC_private.h RCC_program.c STD_TYPES.h STK_config.h STK_interface.h STK_private.h STK_program.c BIT_MATH.h EXTI_config.h EXTI_interface.h EXTI_private.h EXTI_program.c GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c main.c NVIC_Config.h NVIC_Interface.h NVIC_Private.h NVIC_Program.c LED.c LED.h PushButton.c PushButton.h AFIO_config.h AFIO_interface.h AFIO_private.h AFIO_program.c SCB_config.h SCB_interface.h SCB_private.h SCB_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
